# Keil uVision project Hermit3D_lpc1114.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114FBD48/302 NXP
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(50000000) ELITTLE
  output: Hermit3D_lpc1114
  c flags: Optim=2 uC99=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ./: main.c hermit.h file.c stepper.c l6470.c l6470.h stepper.h cbuffer.c cbuffer.h gcode.c timer.c uart.c uart.h adc.c adc.h
  group FatFs
    ./FatFs/: diskio.h ff.h ffconf.h integer.h ff.c mmc_ssp.c
    ./FatFs/option/: ccsbcs.c
  group xprintf
    ./xprintf/: xprintf.c xprintf.h
  group ::Device
    RTE/Device/LPC1114FBD48_302/: startup_LPC11xx.s system_LPC11xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
